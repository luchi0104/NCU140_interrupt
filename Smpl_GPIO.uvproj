# Keil uVision project Smpl_GPIO.uvproj, settings and files
target Smpl_GPIO (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: NUC140VE3CN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: Smpl_GPIO
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3
  c include: ..\;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\NUC1xx\Include;..\..\..\..\Library\Device\Nuvoton\NUC1xx\Source;..\..\..\..\Library\;..\..\..\..\Library\NUC1xx\Include;..\..\..\..\Library\NUC1xx-LB_002\Include
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC1xx.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group Source files
    ./: startup_NUC1xx.s main.c mygpio.c
    ./: mygpio.h
